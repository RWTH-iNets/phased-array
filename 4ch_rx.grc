<?xml version='1.0' encoding='utf-8'?>
<?grc format='1' created='3.7.11'?>
<flow_graph>
<block>
<key>options</key>
<param><key>id</key><value>top_block</value></param>
<param><key>generate_options</key><value>qt_gui</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>range_offset_01</value></param>
<param><key>value</key><value>0.9684</value></param>
<param><key>label</key><value>Offset 01</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-np.pi</value></param>
<param><key>step</key><value>0.001</value></param>
<param><key>stop</key><value>np.pi</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>range_offset_02</value></param>
<param><key>value</key><value>-1.0516</value></param>
<param><key>label</key><value>Offset 02</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-np.pi</value></param>
<param><key>step</key><value>0.001</value></param>
<param><key>stop</key><value>np.pi</value></param>
</block>
<block>
<key>variable_qtgui_range</key>
<param><key>id</key><value>range_offset_03</value></param>
<param><key>value</key><value>-0.8816</value></param>
<param><key>label</key><value>Offset 03</value></param>
<param><key>orient</key><value>Qt.Horizontal</value></param>
<param><key>start</key><value>-np.pi</value></param>
<param><key>step</key><value>0.001</value></param>
<param><key>stop</key><value>np.pi</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>rx_freq</value></param>
<param><key>value</key><value>3.7e9</value></param>
</block>
<block>
<key>variable</key>
<param><key>id</key><value>samp_rate</value></param>
<param><key>value</key><value>1e6</value></param>
</block>
<block>
<key>import</key>
<param><key>id</key><value>import_0</value></param>
<param><key>import</key><value>import numpy as np</value></param>
</block>
<block>
<key>qtgui_freq_sink_x</key>
<param><key>id</key><value>qtgui_freq_sink_x_0</value></param>
<param><key>bw</key><value>samp_rate</value></param>
<param><key>fc</key><value>0</value></param>
<param><key>fftsize</key><value>1024</value></param>
<param><key>showports</key><value>True</value></param>
<param><key>type</key><value>complex</value></param>
<param><key>wintype</key><value>firdes.WIN_BLACKMAN_hARRIS</value></param>
</block>
<block>
<key>qtgui_time_sink_x</key>
<param><key>id</key><value>qtgui_time_sink_x_0</value></param>
<param><key>ctrlpanel</key><value>True</value></param>
<param><key>grid</key><value>True</value></param>
<param><key>color1</key><value>"red"</value></param>
<param><key>label1</key><value>"01"</value></param>
<param><key>marker1</key><value>0</value></param>
<param><key>color2</key><value>"green"</value></param>
<param><key>label2</key><value>"02"</value></param>
<param><key>marker2</key><value>0</value></param>
<param><key>color3</key><value>"blue"</value></param>
<param><key>label3</key><value>"03"</value></param>
<param><key>marker3</key><value>0</value></param>
<param><key>color4</key><value>"green"</value></param>
<param><key>label4</key><value></value></param>
<param><key>style4</key><value>4</value></param>
<param><key>color5</key><value>"blue"</value></param>
<param><key>label5</key><value></value></param>
<param><key>color6</key><value>"blue"</value></param>
<param><key>label6</key><value></value></param>
<param><key>style6</key><value>4</value></param>
<param><key>color7</key><value>"magenta"</value></param>
<param><key>label7</key><value></value></param>
<param><key>color8</key><value>"magenta"</value></param>
<param><key>label8</key><value></value></param>
<param><key>style8</key><value>4</value></param>
<param><key>nconnections</key><value>4</value></param>
<param><key>size</key><value>4096</value></param>
<param><key>srate</key><value>samp_rate</value></param>
<param><key>type</key><value>complex</value></param>
</block>
<block>
<key>uhd_usrp_source</key>
<param><key>id</key><value>uhd_usrp_source_0</value></param>
<param><key>ant0</key><value></value></param>
<param><key>center_freq0</key><value>rx_freq</value></param>
<param><key>dc_offs_enb0</key><value>""</value></param>
<param><key>iq_imbal_enb0</key><value>""</value></param>
<param><key>norm_gain0</key><value>False</value></param>
<param><key>gain0</key><value>15</value></param>
<param><key>ant1</key><value></value></param>
<param><key>center_freq1</key><value>rx_freq</value></param>
<param><key>dc_offs_enb1</key><value>""</value></param>
<param><key>iq_imbal_enb1</key><value>""</value></param>
<param><key>norm_gain1</key><value>False</value></param>
<param><key>gain1</key><value>15</value></param>
<param><key>ant2</key><value></value></param>
<param><key>center_freq2</key><value>rx_freq</value></param>
<param><key>dc_offs_enb2</key><value>""</value></param>
<param><key>iq_imbal_enb2</key><value>""</value></param>
<param><key>norm_gain2</key><value>False</value></param>
<param><key>gain2</key><value>15</value></param>
<param><key>ant3</key><value></value></param>
<param><key>center_freq3</key><value>rx_freq</value></param>
<param><key>dc_offs_enb3</key><value>""</value></param>
<param><key>iq_imbal_enb3</key><value>""</value></param>
<param><key>norm_gain3</key><value>False</value></param>
<param><key>gain3</key><value>15</value></param>
<param><key>clock_rate</key><value>200e6</value></param>
<param><key>dev_addr</key><value>"addr0=192.168.10.2, addr1=192.168.10.3"</value></param>
<param><key>clock_source0</key><value>external</value></param>
<param><key>sd_spec0</key><value>"A:0 B:0"</value></param>
<param><key>time_source0</key><value>external</value></param>
<param><key>clock_source1</key><value>external</value></param>
<param><key>sd_spec1</key><value>"A:0 B:0"</value></param>
<param><key>time_source1</key><value>external</value></param>
<param><key>nchan</key><value>4</value></param>
<param><key>num_mboards</key><value>2</value></param>
<param><key>type</key><value>fc32</value></param>
<param><key>samp_rate</key><value>samp_rate</value></param>
<param><key>hide_cmd_port</key><value>False</value></param>
<param><key>hide_lo_controls</key><value>True</value></param>
<param><key>sync</key><value>sync</value></param>
</block>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>qtgui_freq_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>0</source_key><sink_key>0</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>1</source_key><sink_key>1</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>2</source_key><sink_key>2</sink_key></connection>
<connection><source_block_id>uhd_usrp_source_0</source_block_id><sink_block_id>qtgui_time_sink_x_0</sink_block_id><source_key>3</source_key><sink_key>3</sink_key></connection>
</flow_graph>
